# Keil uVision project Lab 3.uvproj, settings and files
target Lab 3 (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Lab 3
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: main.c startup_stm32f0xx.s
    C:/Keil/ARM/Startup/ST/STM32F0xx/: system_stm32f0xx.c
